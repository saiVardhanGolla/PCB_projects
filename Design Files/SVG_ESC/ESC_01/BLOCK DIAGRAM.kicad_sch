File: Design Files/SVG_ESC/ESC_01/BLOCK DIAGRAM.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: 0.01
Other:
- note added: "0-60V"
